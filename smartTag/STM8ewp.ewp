# IAR project STM8ewp.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\lib\SPL; ..\lib\boardCj
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCIncludePath2: ..\lib\boardCj; ..\lib\SPL
  OBJCOPY.OOCOutputFile: STM8ewp.srec
  ILINK.IlinkOutputFile: STM8ewp.out
  group (top)
    ./: interface.c interface.h main.c
  group library
    ../lib/boardCj/: board.c board.h mcuPinOut.h
  group SPL
    ../lib/SPL/: stm8s.h stm8s_adc1.c stm8s_adc1.h stm8s_awu.c stm8s_awu.h stm8s_beep.c stm8s_beep.h stm8s_clk.c stm8s_clk.h stm8s_conf.h stm8s_exti.c stm8s_exti.h stm8s_flash.c stm8s_flash.h stm8s_gpio.c stm8s_gpio.h stm8s_i2c.c stm8s_i2c.h stm8s_itc.c stm8s_itc.h stm8s_iwdg.c stm8s_iwdg.h stm8s_rst.c stm8s_rst.h stm8s_spi.c stm8s_spi.h stm8s_tim1.c stm8s_tim1.h stm8s_tim2.c stm8s_tim2.h stm8s_tim4.c stm8s_tim4.h stm8s_uart1.c stm8s_uart1.h stm8s_wwdg.c stm8s_wwdg.h
